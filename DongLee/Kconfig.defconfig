## DongLee/Kconfig.defconfig
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_DONGLEE

config ZMK_KEYBOARD_NAME
    default "DongLee"

endif
```
